Commit message: stop using external urdfs

File: cylinder.urdf (robot description, URDF)
Before this commit: robot stable_cylinder, 1 links, 0 joints
Links:
- link cylinder: geometry collision cylinder length=0.2 radius=0.05; visual cylinder length=0.2 radius=0.05
